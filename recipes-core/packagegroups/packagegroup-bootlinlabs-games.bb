SUMMARY = "Bootlin games"

inherit packagegroup

RDEPENDS_${PN} = "ninvaders"